# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Library;..\Support_Drive;..\System;..\User;..\FreeRTOS\src;..\FreeRTOS\port;..\FreeRTOS\include;..\FreeRTOS\Users;.\control;.\LED;.\LightSensor;.\motor;.\Serial;.\servo;..\__MAINCODE__
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ./: main.c main.h
  group Library
    ../Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Support_Drive
    ../Support_Drive/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group System
    ../System/: Delay.c Delay.h
  group User
    ../User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group FreeRTOS/Users
    ../FreeRTOS/Users/: DynamicMemoryTask.c DynamicMemoryTask.h StaticMemoryTask.c StaticMemoryTask.h
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c FreeRTOSConfig.h
  group FreeRTOS/port
    ../FreeRTOS/port/: heap_4.c port.c portmacro.h
  group control
    ./control/: controla.c controla.h controlb.c controlb.h controlc.c controlc.h controld.c controld.h controle.c controle.h
  group LED
    ./LED/: LED.c LED.h
  group LightSensor
    ./LightSensor/: LightSensor.c LightSensor.h
  group motor
    ./motor/: Motors.c Motors.h Motorx.c Motorx.h motory.c motory.h
  group Serial
    ./Serial/: Serial.c Serial.h
  group servo
    ./servo/: PWMAB.c PWMAB.h PWMC.c PWMC.h servoab.c servoab.h servoc.c servoc.h
